VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO AION_nand2_o21ai_11
  CLASS BLOCK ;
  FOREIGN AION_nand2_o21ai_11 ;
  ORIGIN 0.000 0.000 ;
  SIZE 0.005 BY 0.005 ;
END AION_nand2_o21ai_11
END LIBRARY

